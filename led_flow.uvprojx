# Keil uVision project led_flow.uvprojx, settings and files
target led_flow (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x8000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: led_flow +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: E:\keil5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Include;E:\keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c startup_stm32f10x_md.s system_stm32f10x.c
